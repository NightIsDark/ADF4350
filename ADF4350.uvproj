# Keil uVision project ADF4350.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F300 Silicon Labs
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(25000000)
  output: ADF4350 +hex
  c flags: Optimize=9 SizeSpeed=1
  c include: .\Objects;C:\Keil_v5\C51\INC\SiLABS;C:\Keil_v5\C51\INC\SiLABS\shared\si8051Base;.\driver;.\F30x
  group flash
    ./F30x/: F300_FlashPrimitives.c F300_FlashUtils.c
  group User
    ./User/: ADF4350.C ADF4350_IO.C key.c main.c para.c serial.c
  group driver
    ./driver/: init.c STARTUP.A51
